# Keil uVision project SIHAN_LPC824_Gateway.uvprojx, settings and files
target gateway (ARM-ADS)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.1.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SIHAN_LPC824_Gateway +hex
  c flags: Optim=1 wLevel=2
  c include: .\CM0+;.\LPC8xx;.\include
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group LPC8xx
    ./LPC8xx/: system_LPC8xx.c uart.c timer.c gpio.c
    ./LPC8xx/startup/: startup_lpc82x.s
  group user_code
    ./user_code/: main.c queue.c gprs.c rf433m.c wifi.c led.c gw_protocol.c
